# Keil uVision project E80.uvprojx, settings and files
target E80 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: E80 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Radio/lr20xx_driver/src;../Radio/radio_hal;../Radio/lr20xx_driver/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: user_uart.c fifo.c event.c user_radio.c main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Radio/drive
    ../Radio/lr20xx_driver/inc/: lr_fhss_v1_base_types.h lr20xx_driver_version.h lr20xx_hal.h lr20xx_radio_bluetooth_le.h lr20xx_radio_bluetooth_le_types.h lr20xx_radio_bpsk.h lr20xx_radio_bpsk_types.h lr20xx_radio_common.h lr20xx_radio_common_types.h lr20xx_radio_fifo.h lr20xx_radio_fifo_types.h lr20xx_radio_flrc.h lr20xx_radio_flrc_types.h lr20xx_radio_fsk.h lr20xx_radio_fsk_common_types.h lr20xx_radio_fsk_types.h lr20xx_radio_lora.h lr20xx_radio_lora_types.h lr20xx_radio_lr_fhss.h lr20xx_radio_lr_fhss_types.h lr20xx_radio_ook.h lr20xx_radio_ook_types.h lr20xx_radio_oqpsk_15_4.h lr20xx_radio_oqpsk_15_4_types.h lr20xx_radio_wi_sun.h lr20xx_radio_wi_sun_types.h lr20xx_radio_wm_bus.h lr20xx_radio_wm_bus_types.h lr20xx_radio_z_wave.h lr20xx_radio_z_wave_types.h lr20xx_regmem.h lr20xx_rttof.h lr20xx_rttof_types.h lr20xx_status.h lr20xx_system.h lr20xx_system_types.h lr20xx_workarounds.h
    ../Radio/lr20xx_driver/src/: lr20xx_driver_version.c lr20xx_radio_bluetooth_le.c lr20xx_radio_bpsk.c lr20xx_radio_common.c lr20xx_radio_fifo.c lr20xx_radio_flrc.c lr20xx_radio_fsk.c lr20xx_radio_lora.c lr20xx_radio_lr_fhss.c lr20xx_radio_ook.c lr20xx_radio_oqpsk_15_4.c lr20xx_radio_wi_sun.c lr20xx_radio_wm_bus.c lr20xx_radio_z_wave.c lr20xx_regmem.c lr20xx_rttof.c lr20xx_system.c lr20xx_workarounds.c
  group Radio/hal
    ../Radio/radio_hal/: lr20xx_hal.c lr20xx_pa_pwr_cfg.h radio_utilities.c radio_utilities.h
software components: CMSIS:CORE 5.4.0
